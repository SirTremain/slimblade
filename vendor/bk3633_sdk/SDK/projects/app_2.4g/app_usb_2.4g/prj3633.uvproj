# Keil uVision project prj3633.uvproj, settings and files
target Target1 (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk3633_app
  BeforeMake: del.bat
  AfterMake: fromelf --bin --output .\output\app\bk3633_app.bin .\obj\bk3633_app.axf
  AfterMake: .\output\translate.bat
  c flags: Optim=4 uC99=1 wLevel=2
  c define: CFG_CPU_BK3633
  c misc: --gnu
  c include: ..\..\..\src\ip\ble\ll\api;..\..\..\src\ip\ble\ll\import\reg;..\..\..\src\ip\ble\ll\src;..\..\..\src\ip\bt\api;..\..\..\src\ip\bt\import\reg;..\..\..\src\ip\bt\src;..\..\..\src\ip\em\api;..\..\..\src\ip\hci\api;..\..\..\src\ip\sch\api;..\..\..\src\ip\sch\import;..\..\..\src\modules\aes\api;..\..\..\src\modules\common\api;..\..\..\src\modules\dbg\api;..\..\..\src\modules\ecc_p256\api;..\..\..\src\modules\h4tl\api;..\..\..\src\modules\ke\api;..\..\..\src\plf\nvds\api;..\..\..\src\driver\rf;..\..\..\src\plf\rwip\api;..\..\..\src\plf\rwip\import\reg;..\..\..\src\plf\refip\import\reg;..\..\..\src\plf\refip\src\arch;..\..\..\src\plf\refip\src\arch\boot\rvds;..\..\..\src\plf\refip\src\arch\compiler\rvds;..\..\..\src\plf\refip\src\arch\ll\rvds;..\..\..\src\driver\flash;..\..\..\src\driver\led;..\..\..\src\driver\reg;..\..\..\src\driver\syscntl;..\..\..\src\driver\timer;..\..\..\src\driver\uart;..\..\..\src\driver\uart2;..\..\..\Src\header;..\..\..\Src\header\header_file;..\..\..\Src\plf\refip\src\driver;..\..\..\Src\ip\ble\hl\api;..\..\..\Src\ip\ble\hl\inc;..\..\..\Src\ip\ble\hl\src\gap\gapc;..\..\..\Src\ip\ble\hl\src\gap\gapm;..\..\..\Src\ip\ble\hl\src\gatt;..\..\..\Src\ip\ble\hl\src\gatt\attc;..\..\..\Src\ip\ble\hl\src\gatt\attm;..\..\..\Src\ip\ble\hl\src\gatt\atts;..\..\..\Src\ip\ble\hl\src\gatt\gattc;..\..\..\Src\ip\ble\hl\src\gatt\gattm;..\..\..\Src\ip\ble\hl\src\l2c\l2cc;..\..\..\Src\ip\ble\hl\src\l2c\l2cm;..\..\..\Src\app\api;..\..\..\Src\profiles\dis\diss\api;..\..\..\Src\profiles\FEE0\api;..\..\..\Src\profiles\bas\bass\api;..\..\..\Src\profiles\FCC0_128\api;..\..\..\Src\driver\gpio;..\..\..\Src\driver\spi;..\..\..\Src\driver\icu;..\..\..\Src\driver\wdt;..\..\..\Src\driver\adc;..\..\..\Src\profiles\ancs\ancsc\api;..\..\..\Src\profiles\oad\api;..\..\..\Src\profiles\ancs\ancsc;.\system;.\app\api;..\..\..\src\driver\uart2;..\..\..\src\driver\aon_rtc;..\..\..\src\plf\prf;..\..\..\Src\driver\intc;..\..\..\src\driver\dma;..\..\..\src\driver\i2c;..\..\..\src\device\lcd;..\..\..\src\device\spi_flash;..\..\..\src\driver\usb;..\..\..\src\driver\usb\include;..\..\..\src\driver\usb\include\class;..\..\..\src\driver\usb\src\cd;..\..\..\src\driver\usb\src\drivers\comm;..\..\..\src\driver\usb\src\drivers\msd;..\..\..\src\driver\usb\src\examples;..\..\..\src\driver\usb\src\functions\trans_fn;..\..\..\src\driver\usb\src\systems\none;..\..\..\src\driver\usb\src\systems\none\afs;..\..\..\src\driver\usb\src\test;..\..\..\src\driver\usb\src\test\msd;.\app\src\2.4;..\..\..\src\driver\sensor;..\..\..\src\driver\timer;..\..\..\src\driver\flash
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x400000 size 0x10000
  scatter file: ..\..\..\src\system\app_24_link.txt
  link misc: --entry sys_Reset
  group system
    ./system/: handlers.s vectors.s user_config.h
    ./app/src/: main.c intc.c
  group app
    ./app/src/: app.c
  group driver
    ../../../Src/driver/flash/: flash.c
    ../../../Src/driver/rf/: rf_xvr_24.c
    ../../../Src/driver/gpio/: gpio.c
    ../../../Src/driver/spi/: spi.c
    ../../../Src/driver/icu/: icu.c
    ../../../Src/driver/wdt/: wdt.c
    ../../../Src/driver/adc/: adc.c
    ../../../Src/driver/uart2/: uart2.c
    ../../../src/driver/uart/: uart.c
    ../../../src/driver/aon_rtc/: aon_rtc.c
    ../../../src/driver/i2c/: i2c.c
    ../../../src/driver/dma/: dma.c
    ../../../src/driver/timer/: driver_timer.c
    ../../../src/driver/sensor/: driver_sensor.c
  group usb
    ../../../src/driver/usb/src/cd/: mu_cntlr.c mu_descs.c mu_drc.c mu_fc.c mu_fdr.c mu_fun_24.c mu_hc.c mu_hdr.c mu_list.c mu_hst.c mu_pip.c
    ../../../src/driver/usb/src/examples/msd/: mu_msdfn_24.c
    ../../../src/driver/usb/src/functions/trans_fn/: mu_tfunc.c
    ../../../src/driver/usb/src/systems/none/: plat_uds.c
    ../../../src/driver/usb/src/systems/none/afs/: board.c
    ../../../src/driver/usb/src/test/msd/: tst_msd.c
    ../../../src/driver/usb/: driver_usb.c
  group rf
    ./app/src/2.4/: application_main.c APPLICATION_MODE_NORMAL.c application_mode_page.c application_mode_PCBA.c APPLICATION_MODE_TEST.C application_rf.c driver_rf.c
